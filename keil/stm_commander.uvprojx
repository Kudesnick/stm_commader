# Keil uVision project stm_commander.uvprojx, settings and files
target nucleo-f103RB (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm_commander +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c include: ..\src;..\src\bsp;..\src\fnt;..\src\ossp;..\src\thrd
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp
    ../src/bsp/: bsp_ili9341.cpp bsp_track_point.cpp bsp_sdcard.cpp
  group fnt
    ../src/fnt/: atari.cpp courier_new.cpp cpp_font.cpp fnt8x8.cpp fnt8x16.cpp zx.cpp
  group ossp
    ../src/ossp/: cpp_list.cpp cpp_os.cpp
  group src
    ../src/: cpp_terminal.cpp user_main.cpp
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
target nucleo-L476RG (6100001::V6.10.1::.\ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm_commander +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c include: ..\src;..\src\bsp;..\src\fnt;..\src\ossp;..\src\thrd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:I/O:File 1.2.0, File System:CORE 6.11.0, File System:Drive:Memory Card 6.11.0, Board Support:LED 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:SPI 2.2, CMSIS Driver:SPI 1.2.0, CMSIS Driver:SPI:Multi-Slave 1.0.1, Device:DMA 1.2, Device:GPIO 1.3, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:STM32Cube LL:Common 1.9.0, Device:STM32Cube LL:GPIO 1.9.0, Device:STM32Cube LL:PWR 1.9.0, Device:STM32Cube LL:RCC 1.9.0, Device:STM32Cube LL:UTILS 1.9.0, Device:Startup 1.0.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0
